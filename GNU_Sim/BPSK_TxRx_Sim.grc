options:
  parameters:
    generate_options: qt_gui
    id: BPSK_TxRx_Sim
    output_language: python
    title: BPSK Tx Rx Sim
  states: {}

blocks:
- name: costas_bandwidth
  id: variable_qtgui_range
  parameters:
    label: costas_bw
    start: '0.000'
    step: '0.005'
    stop: '0.2'
    value: '0.0'
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-3'
    stop: '20e-3'
    value: '5e-3'
  states: {}
- name: freq_off
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1e-6'
    stop: '20e-6'
    value: '5e-6'
  states: {}
- name: mod_order
  id: variable
  parameters:
    value: xpsk_const.arity()
  states: {}
- name: noise_pwr
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.5'
  states: {}
- name: roll_off
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 1e6
    step: 1e6
    stop: 20e6
    value: 1e6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sync_bandwidth
  id: variable_qtgui_range
  parameters:
    label: sym_sync_bw
    start: '0'
    step: '0.005'
    stop: '0.1'
    value: '0.05'
  states: {}
- name: xpsk_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1'
    type: complex
  states: {}
- name: analog_random_uniform_source_x_0
  id: analog_random_uniform_source_x
  parameters:
    maximum: '255'
    minimum: '0'
    seed: '0'
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/anagh/Post_AGC_IQ.dat
    type: complex
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/anagh/Post_SymbolSync.dat
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: len(Header_Payload_Formatter.generate_header_payload())*50
    type: byte
  states: {state: bypassed}
- name: blocks_head_1
  id: blocks_head
  parameters:
    num_items: 1024*4096*8
    type: complex
  states: {state: bypassed}
- name: blocks_head_1_0
  id: blocks_head
  parameters:
    num_items: 1024*4099
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 7/10
    type: complex
  states: {state: bypassed}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: int(mod_order**.5)
    l: '1'
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    display: 'False'
    name: Debugger
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_uchar_to_float_0_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: int(mod_order**.5)
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: Header_Payload_Formatter.generate_header_payload()
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: 1.0 + epsilon
    freq_offset: freq_off
    noise_voltage: noise_pwr
    seed: '0'
    taps: 1.0 + 0
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: xpsk_const
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: xpsk_const
    differential: 'True'
    excess_bw: roll_off
    samples_per_symbol: sps
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '00001100110111100010001100101111'
    tagname: packet_len
    threshold: '0'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: mod_order
    w: costas_bandwidth
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: mod_order
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sync_bandwidth
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import sys; sys.path.append('/home/anagh/Repos/RadioShift/GNU Radio/GNU'); import Header_Payload_Formatter
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"TX Signal IQ"'
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"Rx Signal IQ"'
    size: '1024'
    type: complex
    xmax: '3'
    xmin: '-3'
    ymax: '3'
    ymin: '-3'
  states: {}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: Post Symbol Sync
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: Post Costas Loop
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: Pre-RRC Constellation
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    label1: Pure Signal
    label2: Squared Signal
    nconnections: '2'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"TX Signal Timeseries"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"TX Byte Stream"'
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: RX Byte Stream
    size: '1024'
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: int(11*sps)
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_0_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: int(11*sps)
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: bb_channel_signal
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: bb_channel_signal
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_head_1, '0']
- [analog_agc2_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [analog_agc2_xx_0, '0', root_raised_cosine_filter_0, '0']
- [analog_random_uniform_source_x_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_head_1, '0', blocks_file_sink_0, '0']
- [blocks_head_1_0, '0', blocks_file_sink_0_0, '0']
- [blocks_multiply_const_vxx_0, '0', channels_channel_model_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_repack_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_throttle_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_uchar_to_float_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_uchar_to_float_0_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_constellation_modulator_0, '0']
- [blocks_vector_source_x_1_0, '0', blocks_head_0, '0']
- [channels_channel_model_0, '0', virtual_sink_0, '0']
- [dc_blocker_xx_0, '0', analog_agc2_xx_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', qtgui_const_sink_x_0_1, '0']
- [digital_constellation_modulator_0, '0', root_raised_cosine_filter_0_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tag_debug_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_0_1, '0']
- [digital_diff_decoder_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_head_1_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_0_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_0, '0']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_0, '1']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [root_raised_cosine_filter_0_0, '0', blocks_throttle_0, '0']
- [virtual_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
