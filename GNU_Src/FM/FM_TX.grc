options:
  parameters:
    author: phu
    generate_options: qt_gui
    id: FM_TX
    output_language: python
    title: FM_TX
  states: {}

blocks:
- name: audio_rate
  id: variable
  parameters:
    value: '24000'
  states: {}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: quad_rate
  id: variable
  parameters:
    value: audio_rate*10
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    comment: |-
      FM modulation
      input: audio_rate
      output: audio_rate * 10
      or any integer multiples
      10 is chosen arbitrarily
    fh: '-1.0'
    max_dev: 75e3
    quad_rate: quad_rate
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: |-
      output to speaker for debug
      disable if you dont use speaker
    samp_rate: audio_rate
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: |-
      audio rate. 
      Check your audio file property
    file: /home/phu/repos/RadioShiftSDR/local_sandbox/pilot_speaking.mp3
    repeat: 'True'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: quad_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: quad_rate
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_addr: serial=324DD14
    gain0: '20'
    samp_rate: quad_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_wfm_tx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_wfm_tx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_wfm_tx_0, '0', uhd_usrp_sink_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
