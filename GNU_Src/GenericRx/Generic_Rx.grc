options:
  parameters:
    generate_options: qt_gui
    id: Generic_RX
    output_language: python
    title: Generic_Rx
  states: {}

blocks:
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 87.9*10**6
    step: 200*10**3
    stop: 107.9*10**6
    value: 90.9*10**6
  states: {}
- name: rx_chooser
  id: variable_qtgui_chooser
  parameters:
    label0: monitoring
    label1: saving
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2*10**6
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '12'
    quad_rate: 16000*12
  states: {state: disabled}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '16000'
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    comment: |-
      Ensure you are collecting actual artifical RF signal,
      and not just ambient RF noise.

      artifical RF signal usually appears when theres a spike 
      at our center frequency in the frequency sink GUI
    file: f"/home/phu/repos/RadioShiftSDR/fm_complex_samples/IQ_samples_samp_rate_{samp_rate}.bin"
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    comment: |-
      Saving how many I+Q samples to file
      Lets say we want to save
      5 frames,
      each frames has 1024 IQ samples
      so value is set to 5*1024 = 5120
      The flow graph will immediately stop
      after saving 5120
    num_items: 5*1024
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    comment: |-
      chossing between
      1. monitoring: discarding samples,
      	only viewed by GUI, no save to file
      2. saving: saving to file
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: rx_chooser
    type: complex
  states: {}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    comment: |-
      Skipping how many IQ samples
      at the start before we save to file
    num_items: '10000'
    type: complex
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '32'
    long_form: 'True'
    type: cc
  states: {state: bypassed}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    comment: |-
      Some GUI stuff for debugging
      Checking whether you are collecting just
      ambient RF noise
      or
      actual RF signal transmitted.

      Usually human maded RF signal has a spike at certain frequency.
      Check the Frequency Sink
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    color1: '1'
    fc: '0'
    fftsize: '1024'
    type: complex
    wintype: window.WIN_HAMMING
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    comment: |-
      (Optional) Just for fun
      If you are tuning into FM radio station,
      this will demodulate the signal with FM modulation scheme
      Output is audio signal coming into your speaker

      Otherwise, you can just disable all from this block to Audio Sink
    decim: '125'
    interp: '12'
    type: ccc
  states: {state: bypassed}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"TX/RX"'
    center_freq0: freq
    dev_addr: type=b200
    dev_args: '""'
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_selector_0, '0']
- [analog_agc2_xx_0, '0', qtgui_const_sink_x_0, '0']
- [analog_agc2_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [analog_agc2_xx_0, '0', qtgui_time_sink_x_0, '0']
- [analog_agc2_xx_0, '0', qtgui_waterfall_sink_x_0, '0']
- [analog_agc2_xx_0, '0', rational_resampler_xxx_0, '0']
- [analog_wfm_rcv_0, '0', audio_sink_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_skiphead_0, '0']
- [blocks_skiphead_0, '0', blocks_head_0, '0']
- [dc_blocker_xx_0, '0', analog_agc2_xx_0, '0']
- [rational_resampler_xxx_0, '0', analog_wfm_rcv_0, '0']
- [uhd_usrp_source_0, '0', dc_blocker_xx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
