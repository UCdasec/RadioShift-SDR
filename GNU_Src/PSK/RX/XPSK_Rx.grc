options:
  parameters:
    generate_options: qt_gui
    id: XPSK_Rx
    output_language: python
    title: XPSK_Rx
  states: {}

blocks:
- name: center_freq
  id: variable_qtgui_range
  parameters:
    start: 915*10**6-(10*5000)
    step: samp_rate
    stop: 915*10**6+(10*5000)
    value: 915*10**6
  states: {state: disabled}
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: costas_loop_bw
  id: variable_qtgui_range
  parameters:
    label: cl_bw
    start: '0.001'
    step: '0.005'
    stop: 0.2*(mod_order/2)
    value: 0.03*(mod_order/2)
  states: {}
- name: mod_order
  id: variable
  parameters:
    value: xpsk_const.arity()
  states: {}
- name: roll_off
  id: variable
  parameters:
    value: '.35'
  states: {}
- name: rx_chooser
  id: variable_qtgui_chooser
  parameters:
    label0: '''Monitor'''
    label1: '''Capture'''
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: rx_gain
  id: variable_qtgui_range
  parameters:
    label: Rx Gain
    start: '0'
    step: '1'
    stop: '80'
    value: '22'
  states: {}
- name: samp_rate
  id: variable_qtgui_range
  parameters:
    start: 1*10**6
    step: 1e6
    stop: 20*10**6
    value: 1*10**6
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: sync_bw
  id: variable_qtgui_range
  parameters:
    label: sync_bw_val
    start: '0'
    step: '0.005'
    stop: 0.07*(mod_order/2)
    value: 0.01*(mod_order/2)
  states: {}
- name: xpsk_const
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-2'
    decay_rate: '1e-4'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/anagh/test_qpsk.dat
    type: byte
    unbuffered: 'True'
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: /home/anagh/Documents/8PSK_Pre_Processing.dat
    type: complex
  states: {}
- name: blocks_file_sink_1_0
  id: blocks_file_sink
  parameters:
    file: /home/anagh/Documents/8PSK_Post_Processing.dat
    type: complex
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(5.12e6)
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: int(math.log2(mod_order))
    l: '1'
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: rx_chooser
    type: complex
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: rx_chooser
    type: complex
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    name: Debugger
    type: byte
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    filter: '"snr"'
    name: SNR
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_align_0
  id: blocks_tagged_stream_align
  parameters:
    lengthtagname: packet_len
    type: byte
  states: {state: bypassed}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '256'
    long_form: 'True'
    type: cc
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: xpsk_const
  states: {}
- name: digital_correlate_access_code_xx_ts_0
  id: digital_correlate_access_code_xx_ts
  parameters:
    access_code: '00001100110111100010001100101111'
    tagname: packet_len
    threshold: '4'
    type: byte
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: mod_order
    w: costas_loop_bw
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: mod_order
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '0'
  states: {state: bypassed}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: sync_bw
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: sps
    ted_gain: '1.0'
    ted_type: digital.TED_GARDNER
    type: cc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import uhd
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    name: '"Raw Samples"'
    size: '1024'
    type: complex
    update_time: '.2'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: Post DC Blocker + AGC"
    size: '1024'
    type: complex
    update_time: '.2'
  states: {}
- name: qtgui_const_sink_x_0_1
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"Post Costas"'
    size: '1024'
    type: complex
    update_time: '.2'
  states: {}
- name: qtgui_const_sink_x_0_2
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    name: '"Post Symbol Sync"'
    size: '1024'
    type: complex
    update_time: '.2'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate*2
    fc: center_freq
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: Decoder
    name: '"Demodulated Signal"'
    size: '1024'
    srate: samp_rate
    tr_level: '.5'
    tr_mode: qtgui.TRIG_MODE_AUTO
    type: float
    ymax: '1.5'
    ymin: '-.5'
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: roll_off
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: samp_rate/sps
    type: fir_filter_ccf
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: uhd.tune_request(center_freq, 1e6)
    dev_addr: type=b200
    dev_args: '""'
    gain0: rx_gain
    rx_agc0: Disabled
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_selector_0, '0']
- [analog_agc2_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [analog_agc2_xx_0, '0', root_raised_cosine_filter_0, '0']
- [blocks_char_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_head_0, '0', blocks_file_sink_1_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_char_to_float_0, '0']
- [blocks_repack_bits_bb_0, '0', digital_correlate_access_code_xx_ts_0, '0']
- [blocks_selector_0, '0', blocks_null_sink_0, '0']
- [blocks_selector_0, '1', blocks_file_sink_1, '0']
- [blocks_selector_0_0, '0', blocks_null_sink_0_0, '0']
- [blocks_selector_0_0, '1', blocks_head_0, '0']
- [blocks_tagged_stream_align_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_file_sink_0, '0']
- [dc_blocker_xx_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tag_debug_0, '0']
- [digital_correlate_access_code_xx_ts_0, '0', blocks_tagged_stream_align_0, '0']
- [digital_costas_loop_cc_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0_1, '0']
- [digital_diff_decoder_bb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', analog_agc2_xx_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', blocks_tag_debug_0_0, '0']
- [digital_symbol_sync_xx_0, '0', blocks_selector_0_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [digital_symbol_sync_xx_0, '0', qtgui_const_sink_x_0_2, '0']
- [root_raised_cosine_filter_0, '0', digital_symbol_sync_xx_0, '0']
- [root_raised_cosine_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', dc_blocker_xx_0, '0']
- [uhd_usrp_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
