options:
  parameters:
    author: phu
    generate_options: qt_gui
    id: NoiseJammer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_freq
  id: variable
  parameters:
    value: 915e6
  states: {}
- name: cut_off_freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      FM typically deviates within +/- 75kHz range
      so we only need to target a 100kHz cut off
    label: cut_off_freq
    start: 50e3
    step: 10e3
    stop: 200e3
    value: 100e3
  states: {}
- name: j_power
  id: variable_qtgui_range
  parameters:
    comment: |-
      digital multiplier
      any value above 1.0 
      may be clipped by gnuradio.
      To actual amplify noise,
      increase tx_gain instead
    start: '0'
    step: '0.1'
    stop: '3'
    value: '0'
  states: {}
- name: j_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: cut_off_freq
    gain: '1'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 400e3
  states: {}
- name: tx_gain
  id: variable_qtgui_range
  parameters:
    label: Tx_gain
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: analog_noise_source_x_0
  id: analog_noise_source_x
  parameters:
    amp: j_power
    noise_type: analog.GR_GAUSSIAN
    seed: '0'
    type: complex
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: j_taps
    type: ccc
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    center_freq0: center_freq
    dev_addr: '"type=b200"'
    gain0: tx_gain
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_noise_source_x_0, '0', fft_filter_xxx_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', uhd_usrp_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
